# Keil uVision project toy_RemoteController_V2_Rx_AT8236(V24_Postback).uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: toy_RemoteController_V2_Rx_AT8236(V24_Postback) +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\_libs;..\my_stc8h_lib_For_V2.4
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
    ../my_stc8h_lib_For_V2.4/: my_nRF24L01.c my_nRF24L01.h my_stc8h_lib.c my_stc8h_lib.h my_stc8h_lib_Isr.c
  group lib
    ./_libs/: Config.h STC8H.h STC8G_H_ADC.c STC8G_H_ADC.h STC8G_H_ADC_Isr.c
