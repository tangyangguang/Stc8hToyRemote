# Keil uVision project toy_RemoteController_V2_Tx_joystick(v24_2Brake_PinSW2_VoltCheck_Postback).uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: toy_RemoteController_TX_V24 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\_libs;..\my_stc8h_lib_For_V2.4
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c
    ../my_stc8h_lib_For_V2.4/: my_nRF24L01.c my_nRF24L01.h my_stc8h_lib.c my_stc8h_lib.h my_stc8h_lib_Isr.c
  group lib
    ./_libs/: STC8G_H_ADC.c STC8G_H_ADC.h STC8G_H_ADC_Isr.c STC8H.h TM1637.c TM1637.h Type_def.h
